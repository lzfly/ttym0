# Keil uVision project we26n.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F071CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: we26n +hex
  c flags: Optim=1 wLevel=2
  c include: .\cmsis;.\starts;.\stlibs\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group starts
    ./starts/: system_stm32f0xx.c startup_stm32f072.s stm32f0xx.h system_stm32f0xx.h
  group cmsis
    ./cmsis/: core_cm0.h core_cmFunc.h core_cmInstr.h
  group stlibs
    ./stlibs/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_syscfg.c stm32f0xx_rtc.c stm32f0xx_flash.c
  group mymy
    ./mymy/: test.c myuart.c myqueue.c mysvch.c mymsg.c systick.c
